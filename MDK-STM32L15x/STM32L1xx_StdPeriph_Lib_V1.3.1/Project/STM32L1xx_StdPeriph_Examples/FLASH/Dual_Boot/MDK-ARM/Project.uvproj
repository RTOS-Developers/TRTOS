# Keil uVision project Project.uvproj, settings and files
target STM32L152D-EVAL BANK1 (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: IROM(0x08000000,0x60000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(32000000) ELITTLE
  output: STM32L152D-EVAL_BANK1
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL, BOOT_FROM_BANK1
  c include: ..\;..\..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\..\Utilities\STM32_EVAL\Common;..\..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group User
    ../: stm32l1xx_it.c main.c
  group StdPeriph_Driver
    ../../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_usart.c misc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_dma.c stm32l1xx_sdio.c stm32l1xx_spi.c
  group CMSIS
    ../: system_stm32l1xx.c
  group STM32L152D_EVAL
    ../../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval_lcd.c stm32l152d_eval.c
  group MDK-ARM
    ../../../../../Libraries/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l1xx_hd.s
  group Doc
    ../: readme.txt
target STM32L152D-EVAL BANK2 (ARM-ADS)
  device: STM32L152ZD STMicroelectronics
  cpu: as above
  output: STM32L152D-EVAL_BANK2
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_HD, USE_STM32L152D_EVAL, BOOT_FROM_BANK2
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8030000 size 0x30000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
